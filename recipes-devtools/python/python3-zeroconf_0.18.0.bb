SUMMARY = "Pure Python Multicast DNS Service Discovery Library (Bonjour/Avahi compatible)"
HOMEPAGE = "https://github.com/jstasiak/python-zeroconf"
LICENSE = "LGPLv2"
LIC_FILES_CHKSUM = "file://setup.py;md5=70397cd15372054e6dd97a6565a38dc0"

SRC_URI[md5sum] = "c168b246337a1b3cbbc1b80a5fc653b3"
SRC_URI[sha256sum] = "c2cbcd7c54fa078afba47ab0c2125f487fd8465d4d398a9a4a01122836202868"

inherit pypi setuptools3
