SUMMARY = "Portable network interface information."
HOMEPAGE = "https://bitbucket.org/al45tair/netifaces"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;md5=fd62088b12d7313347f309cd2f5e444c"

SRC_URI[md5sum] = "5b4d1f1310ed279e6df27ef3a9b71519"
SRC_URI[sha256sum] = "59d8ad52dd3116fcb6635e175751b250dc783fb011adba539558bd764e5d628b"

inherit pypi setuptools3
